# Keil uVision project FM33FG0XXA_Tester.uvprojx, settings and files
target Example (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: FM33FG06XA FMSH
  pack: FMSH.FM33FG0XXA_DFP.0.0.6
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: FM33FG0xxA_Tester +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: FM33FG0XXA,USE_FULL_ASSERT
  c include: ..\Drivers\CMSIS\Inculde;..\Drivers\CMSIS\Device\FM\FM33xx\Include;..\Drivers\FM33FG0xxA_FL_Driver\Inc;..\MF-config\Inc;..\Inc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/FM/FM33xx/Source/Templates/ARM/: startup_fm33fg0xxa.s
  group Application/MF-config
    ../MF-config/Src/: mf_config.c
  group Application/User
    ../Src/: main.c can.c iwdt.c rmu.c svd.c clock.c lptim16.c gpio.c adc.c pump_pwm.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/FM/FM33xx/Source/: system_fm33fg0xxa.c
  group Drivers/FM33FG0xxA_FL_Driver
    ../Drivers/FM33FG0xxA_FL_Driver/Src/: fm33fg0xxa_fl.c fm33fg0xxa_fl_adc.c fm33fg0xxa_fl_aes.c fm33fg0xxa_fl_atim.c fm33fg0xxa_fl_bstim16.c fm33fg0xxa_fl_bstim32.c fm33fg0xxa_fl_can.c fm33fg0xxa_fl_canfd.c fm33fg0xxa_fl_clm.c fm33fg0xxa_fl_cmu.c fm33fg0xxa_fl_comp.c fm33fg0xxa_fl_crc.c fm33fg0xxa_fl_dac.c fm33fg0xxa_fl_dma.c fm33fg0xxa_fl_exti.c fm33fg0xxa_fl_flash.c fm33fg0xxa_fl_gpio.c fm33fg0xxa_fl_gptim.c fm33fg0xxa_fl_hdiv.c fm33fg0xxa_fl_i2c_master.c fm33fg0xxa_fl_i2c_smbus.c fm33fg0xxa_fl_iwdt.c fm33fg0xxa_fl_lptim16.c fm33fg0xxa_fl_lptim32.c fm33fg0xxa_fl_lpuart.c fm33fg0xxa_fl_pgl.c fm33fg0xxa_fl_pmu.c fm33fg0xxa_fl_rng.c fm33fg0xxa_fl_rtc.c fm33fg0xxa_fl_sent.c fm33fg0xxa_fl_spi.c fm33fg0xxa_fl_svd.c fm33fg0xxa_fl_tau.c fm33fg0xxa_fl_uart.c fm33fg0xxa_fl_wwdt.c
